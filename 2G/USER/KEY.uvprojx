# Keil uVision project KEY.uvprojx, settings and files
target KEY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KEY +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\DAC;..\HARDWARE\ADC;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\7512;..\HARDWARE\IICHARD;..\HARDWARE\pdata;..\HARDWARE\sht2x;..\HARDWARE\LCD;..\modbus;..\modbus\functions;..\modbus\include;..\modbus\port;..\modbus\rtu;..\HARDWARE\RTC;..\HARDWARE\RELAY;..\HARDWARE\SHT10;..\HARDWARE\DHTxx;..\HARDWARE\sys2;..\HARDWARE\IIC;..\HARDWARE\EXTI;..\HARDWARE\SD3078;..\HARDWARE\gprs
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: system_stm32f10x.c stm32f10x_it.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/7512/: dac7512.c
    ../HARDWARE/sht2x/: SHT2x.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/RELAY/: RELAY.c
    ../HARDWARE/DHTxx/: DHxx.c
    ../HARDWARE/SHT10/: sht10.c
    ../HARDWARE/sys2/: sys2.c
    ../HARDWARE/IICHARD/: stm32_eval_i2c_ee.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/SD3078/: sd3078.c
    ../HARDWARE/gprs/: gprs.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_exti.c
  group README
    ../: README.TXT
